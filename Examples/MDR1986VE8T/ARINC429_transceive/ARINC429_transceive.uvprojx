# Keil uVision project ARINC429_transceive.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MDR32F8 Milandr
  pack: Keil.MDR32F8.1.4
  cpu: IROM(0x20006000,0x2000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: ARINC429_transceive
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x20006000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group user
    ./: main.c
  group ::Board Support
    C:/Keil5/ARM/PACK/Keil/MDR32F8/1.4/Libraries/: spec.c
  group ::Device
    RTE/Device/MDR32F8/: startup_1986ve8t.s
  group ::Drivers
    C:/Keil5/ARM/PACK/Keil/MDR32F8/1.4/Libraries/MDR32F8_StdPeriph_Driver/src/: mdr32f8_arinc_rx.c mdr32f8_arinc_tx.c mdr32f8_clkctrl.c mdr32f8_port.c
software components: CMSIS:CORE 3.30.0, Board Support:Board Setup 1.0.1, Device:Startup 1.3.1, Drivers:ARINC429_rx 1.3.1, Drivers:ARINC429_tx 1.3.1, Drivers:CLKCTRL 1.3.1, Drivers:CONFIG 1.3.1, Drivers:LIB 1.3.1, Drivers:PORT 1.3.1
