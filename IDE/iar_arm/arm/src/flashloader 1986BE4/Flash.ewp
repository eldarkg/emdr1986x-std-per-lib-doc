# IAR project Flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flash.srec
  ILINK.IlinkOutputFile: Flash_MDR1986VBE4_F1xRAM4K.out
  ILINK.IlinkIcfFile: Flash.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ./: main.c
  group framework
    ./: flash_loader.c flash_loader_asm.s
